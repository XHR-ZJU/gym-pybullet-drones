Commit message: 0731 rl

File: gym_pybullet_drones/assets/architrave.urdf (robot description, URDF)
Before this commit: robot architrave, 1 links, 0 joints
Links:
- link base_link: geometry collision box size=0.05 0.05 3.0; visual box size=0.05 0.05 3.0
